TYPE E_StateSortingAuto :
(
	eSortingAuto_DetectBox		:= 0,
	eSortingAuto_CylToWork,
	eSortingAuto_CylToBase
);
END_TYPE
